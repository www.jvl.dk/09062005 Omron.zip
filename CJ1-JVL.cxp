Omron CX-Programmer project NewProject (CX-Programmer 3.20)

# PLC MacExample: CJ1M CPU13

## Global symbols (name address type ; comment)
AdresPointer D108 INT
AttrOfReadParmDP D132 INT  ; Attrinute of read Parameter value for DoParameter
AttributeGetDP D125 INT  ; Attribute to get value for DoParameter
AttributeSetDP D124 INT  ; Attribute to set value for DoParameter
3088.02 BOOL  ; $?St$Bk?_#[396] / Copy of status "InPosition"$?St$Bk?_#[396]
3089.02 BOOL  ; $?St$Bk?_#[397] / Copy of drive "InPosition" $?St$Bk?_#[397]
3089.07 BOOL  ; Copy of drive Enabled
3201.04 BOOL  ; Drive #5 command
3201.05 BOOL  ; Drive #5 command
3205.04 BOOL  ; Drive #6 command
3205.05 BOOL  ; Drive #6 command
3300.00 BOOL  ; Input Phoenix
3301.02 BOOL  ; Drive #5 status
3301.07 BOOL  ; Drive #5 status
3302.02 BOOL  ; Drive #5 status
3302.07 BOOL  ; Drive #5 status
3305.02 BOOL  ; Drive #6 status
3305.07 BOOL  ; Drive #6 status
3306.02 BOOL  ; Drive #6 status
3306.07 BOOL  ; Drive #6 status
33.01 BOOL  ; Drive #5 status
CmdMac 3201 CHANNEL  ; Command bits for mac
CommandMsgType D102 CHANNEL  ; Number for the wanted command.
CommandNode1 3001 CHANNEL  ; Commando flags
CopyDriveStatus 3089 CHANNEL
DelayI1 T0140 BOOL
DelayI2 T0141 BOOL
DelayI3 T0142 BOOL
DoCommand 3091.15 BOOL  ; Execute
DoParameter 3092.15 BOOL  ; Execute
Enable1 3090.14 BOOL  ; EnableServo1
Enable_1 3001.07 BOOL
Enabled_1 3000.07 BOOL  ; Drive status
Enabled_2 3002.07 BOOL
Enabling_1 3201.07 BOOL  ; Drive #5 command
Enabling_2 3205.07 BOOL  ; Drive #6 command
Error H30.00 BOOL  ; Collected error signal
ErrorCode 3070.00 BOOL  ; Activate SUB
ExampDoCommand 3091.14 BOOL  ; Set example parameters
ExampDoParameter 3092.14 BOOL  ; Set example parameters
ExampDoPosCtrlAttr 3094.14 BOOL
ExampleInit 3095.14 BOOL  ; Set example parameters
FirstInitScan 3095.08 BOOL
FwdLimit_1 3000.09 BOOL
FwdLimit_2 3002.09 BOOL
GeneralFault_1 3000.03 BOOL
Hardstop_1 3001.05 BOOL
Hardstop_2 3003.05 BOOL
Incement_2 3205.02 BOOL  ; Drive #6 command
Increment_1 3201.02 BOOL  ; Drive #5 command
Incremental1 3090.00 BOOL  ; Make positions relative
Incremental_1 3001.02 BOOL
Incremental_2 3003.02 BOOL
InitAcceleration D202 DINT  ; Parm for initialize
InitMaxVelocity D200 DINT  ; Parm for initialize
InitNodeAdr D206 DINT  ; Parm for initialize
InitSeqLock 3095.12 BOOL
InitStep0 3095.00 BOOL
InitStep1 3095.01 BOOL
InitStep2 3095.02 BOOL
InitStep3 3095.03 BOOL
InitStep4 3095.04 BOOL
InitStep5 3095.05 BOOL
InitTorqueLimit D204 DINT  ; Parm for initialize
InitializeFun 3095.15 BOOL  ; Activate Initialize
InternalAddressPointer D128 INT  ; Parameter Sub
LoadCompleteMirror 3010.07 BOOL  ; Read by relative addressing
LoadComplete_1 3000.15 BOOL
LoadData_1 3001.00 BOOL
MessagetypeDP D122 INT  ; Set messagetype
MovAcc D162 DINT
MovAddr D166 INT
MovTargetPos D160 DINT
MovVel D164 DINT
MoveCyclicCall 3080.09 BOOL
MoveFirstscan 3080.08 BOOL
MoveFunction 3080.15 BOOL  ; Activate
MoveParmCallOut 3080.14 BOOL  ; Set parms and call Move function
MoveParmCallReturn 3080.13 BOOL  ; Set parms and call Move function
MoveSeqLock 3080.12 BOOL
MoveStep0 3080.00 BOOL
MoveStep1 3080.01 BOOL
MoveStep2 3080.02 BOOL
MoveStep3 3080.03 BOOL
MoveStep4 3080.04 BOOL
MoveStep5 3080.05 BOOL
MoveStep6 3080.06 BOOL
MoveStep7 3080.07 BOOL
NodeAddrDoCmd D103 CHANNEL  ; First address in devicenet area  for which node (drive) the command is valid.
NodeAddres D186 INT
NodeAdrDP D123 INT  ; First address in devicenet area  for which node (drive) the command is valid.
OnTarget_1 3000.02 BOOL  ; I position
OnTarget_2 3002.02 BOOL
ReadParmDP D130 DINT  ; Read Parameter value for DoParameter
RespMsgType D112 INT  ; Type of message response
ResponseMsgtype D104 INT  ; -Number for the wanted response
ResponseValue D110 DINT  ; Response from function call
RevLimit_1 3000.10 BOOL
RevLimit_2 3002.10 BOOL
Smoothstop_1 3001.04 BOOL
Smoothstop_2 3003.04 BOOL
StatusMac 3301 CHANNEL  ; Status bits from Mac
StatusNode1 3000 CHANNEL  ; Upper flags cmd, and lower flag are status
Step0DoCmd 3091.00 BOOL
Step0Parm 3092.00 BOOL
Step1DoCmd 3091.01 BOOL
Step1Parm 3092.01 BOOL
Step2DoCmd 3091.02 BOOL
Step2Parm 3092.02 BOOL
Temp1 D139 CHANNEL  ; Parm Sub,Temp word for internal calculation
Temp2 D136 CHANNEL  ; Parm Sub, Temp word for internal calculation
Temporary D106 INT
TimeOut_DoCommand T0110 BOOL
TimeOut_DoParameter T0111 BOOL
TorqueLimit D184 DINT
TypeZeroSearch D180 DINT
ValueDP D120 DINT  ; Parameter set value for DoParameter
ValueDoCmd D100 DINT  ; Parameter MOV function. Size doubble word
ZeroFirstscan 3093.08 BOOL
ZeroSearch 3093.15 BOOL  ; Activate ZeroSearch
ZeroSearchParm 3093.14 BOOL  ; Set example parameters
ZeroSearchVelocity D182 DINT
ZeroSeqLock 3093.12 BOOL
ZeroStep0 3093.00 BOOL
ZeroStep1 3093.01 BOOL
ZeroStep2 3093.02 BOOL
ZeroStep3 3093.03 BOOL
ZeroStep4 3093.04 BOOL
ZeroStep5 3093.05 BOOL
ZeroStep6 3093.06 BOOL

## Program EasyStart (cyclic task 0)
; Program containing subroutines and example of how to call these routines in order to obtain easy access to MAC drives
Local symbols
DelayI1 BOOL
T01a1 T0131 BOOL

### Section Main_test
; Contains examples of how to manage DoCommand and DoParameter, and DoPositionControllerAttribute for drive handling

; rung 0: Get input from another devicenet input
LD 3300.00  ; Input Phoenix
OUT H0.00
; rung 1: How to make hardwire control of drive
LD 3300.01
OR 3300.01
OUT Hardstop_1
; rung 2: Activate enabling of first servo drive
@LD Enable1  ; EnableServo1
@OR 3300.00  ; Input Phoenix
SET Enable_1
; rung 3: Deactivate enable of first servo drive
%LD Enable1  ; EnableServo1
%OR 3300.00  ; Input Phoenix
RSET Enable_1
; rung 4
LD 3070.14
OUT 3003.07
; rung 5: Make positioning relative, incremental
LD Incremental1  ; Make positions relative
OUT Incremental_1

; rung 6: Parameters for DoCommand function
LD ExampDoCommand  ; Set example parameters
ANDNOT DoParameter  ; Execute
MOV(021) &1 CommandMsgType  ; Number for the wanted command.
MOV(021) &1 NodeAddrDoCmd  ; First address in devicenet area  for which node (drive) the command is valid.
MOV(021) &5 ResponseMsgtype  ; -Number for the wanted response
MOVL(498) &10000 ValueDoCmd  ; Parameter MOV function. Size doubble word
SET DoCommand  ; Execute
RSET ExampDoCommand  ; Set example parameters
; rung 7: Call routine for DoCommand
LD DoCommand  ; Execute
OUT TR0
@AND DoCommand  ; Execute
SET Step0DoCmd
LD TR0
SBS(091) 1  // Call subroutine for function
TIM 0110 #10  ; TimeOut_DoCommand  // Timeout for DoCommand function

; rung 8: Setting parameters for calling DoParameter
LD ExampDoParameter  ; Set example parameters
ANDNOT DoParameter  ; Execute
MOV(021) #1 NodeAdrDP  ; First address in devicenet area  for which node (drive) the command is valid.
MOV(021) #1F MessagetypeDP  ; Set messagetype
MOVL(498) &50 ValueDP  ; Parameter set value for DoParameter
MOV(021) &5 AttributeSetDP  ; Attribute to set value for DoParameter
MOV(021) &14 AttributeGetDP  ; Attribute to get value for DoParameter
RSET ExampDoParameter  ; Set example parameters
SET DoParameter  ; Execute

; rung 9: Setting parameters for calling DoPositionControllerAttribute
LD ExampDoPosCtrlAttr
ANDNOT DoParameter  ; Execute
MOV(021) #1 NodeAdrDP  ; First address in devicenet area  for which node (drive) the command is valid.
MOV(021) #1B MessagetypeDP  ; Set messagetype
MOVL(498) &50 ValueDP  ; Parameter set value for DoParameter
MOV(021) &103 AttributeSetDP  ; Attribute to set value for DoParameter
MOV(021) &102 AttributeGetDP  ; Attribute to get value for DoParameter
RSET ExampDoPosCtrlAttr
SET DoParameter  ; Execute
; rung 10: Call routine for DoParameter AND DoPositionControllerAttribute
LD DoParameter  ; Execute
OUT TR0
@AND DoParameter  ; Execute
SET Step0Parm
LD TR0
SBS(091) 2  // Call subroutine for DoParameter function
TIM 0111 #10  ; TimeOut_DoParameter  // Timeout for function

; rung 11: Setting parameters for ZeroSearch function
LD ZeroSearchParm  ; Set example parameters
MOVL(498) &12 TypeZeroSearch
MOV(021) &1 NodeAddres  // Setting drive name by adrerssing first word at the device net
MOV(021) &3413 ZeroSearchVelocity
MOV(021) &50 TorqueLimit
RSET ZeroSearchParm  ; Set example parameters
SET ZeroSearch  ; Activate ZeroSearch
; rung 12: Call routine for zero search function
LD ZeroSearch  ; Activate ZeroSearch
SBS(091) 0
; rung 13: Setting parameters for ZeroSearch function
LD ExampleInit  ; Set example parameters
MOVL(498) &270000 InitAcceleration  ; Parm for initialize
MOV(021) &1 InitNodeAdr  ; Parm for initialize  // Setting drive name by adrerssing first word at the device net
MOVL(498) &135000 InitMaxVelocity  ; Parm for initialize  // Set 100 RPM
MOVL(498) &512 InitTorqueLimit  ; Parm for initialize
RSET ExampleInit  ; Set example parameters
SET InitializeFun  ; Activate Initialize

; rung 14: Call to initialize
LD InitializeFun  ; Activate Initialize
SBS(091) 5

### Section UseMove
; Examples (2) of how to use MOVE function for simple positioning

; rung 0: Sets parameter for Target position, Velocity, and Acceleration, and first devicenet address. Example has slow acceleration and medium speed
LD MoveParmCallOut  ; Set parms and call Move function
ANDNOT MoveFunction  ; Activate
MOVL(498) &100000 MovTargetPos
MOVL(498) &10000 MovAcc
MOVL(498) #50000 MovVel
MOV(021) #1 MovAddr
RSET MoveParmCallOut  ; Set parms and call Move function
SET MoveFunction  ; Activate
; rung 1: Sets parameter for Target position, Velocity, and Acceleration, and first devicenet address. Example has a low speed fast acceleration
LD MoveParmCallReturn  ; Set parms and call Move function
ANDNOT MoveFunction  ; Activate
MOVL(498) #0 MovTargetPos
MOVL(498) &100000 MovAcc
MOVL(498) #5000 MovVel
MOV(021) #1 MovAddr
RSET MoveParmCallReturn  ; Set parms and call Move function
SET MoveFunction  ; Activate
; rung 2: Activate the Move function, and keep it active till InPosition. Reset by the subroutine
LD MoveFunction  ; Activate
ANDNOT Incremental1  ; Make positions relative
SBS(091) 3

### Section DeviceNetCommon

; rung 0: Get statusbit and set controlbit, network is copied for each node in network. This for node #5 address 3201 and 3301
LD P_On
OUT TR0
AND 3301.07  ; Drive #5 status
OUT Enabled_1  ; Drive status
LD TR0
AND 3301.02  ; Drive #5 status
OUT OnTarget_1  ; I position
LD TR0
AND 3302.02  ; Drive #5 status
OUT FwdLimit_1
LD TR0
AND 3302.07  ; Drive #5 status
OUT RevLimit_1
LD TR0
AND Enable_1
SET Enabling_1  ; Drive #5 command
LD TR0
AND Hardstop_1
OUT 3201.05  ; Drive #5 command
LD TR0
AND Smoothstop_1
OUT 3201.04  ; Drive #5 command
LD TR0
AND Incremental_1
OUT Increment_1  ; Drive #5 command
; rung 1: Get statusbit and set controlbit, network is copied for each node in network. This for node #5 address 3201 and 3301
LD P_On
OUT TR0
AND 3305.07  ; Drive #6 status
OUT Enabled_2
LD TR0
AND 3305.02  ; Drive #6 status
OUT OnTarget_2
LD TR0
AND 3306.02  ; Drive #6 status
OUT FwdLimit_2
LD TR0
AND 3306.07  ; Drive #6 status
OUT RevLimit_2
LD TR0
AND 3003.07
SET Enabling_2  ; Drive #6 command
LD TR0
AND Hardstop_2
OUT 3205.05  ; Drive #6 command
LD TR0
AND Smoothstop_2
OUT 3205.04  ; Drive #6 command
LD TR0
AND Incremental_2
OUT Incement_2  ; Drive #6 command
; rung 3: Word should be 0, when bus running
LD<>(305) 1510 #0
OUT H30.01

; rung 4: Indicates errors or historic errors. Bit0 is Online, bit 15 is error history
LD<>(305) 1511 #800B
OUT H30.02
; rung 5: Bit 15 on for Remete IO communication (running) else an error has occured. 9000h means communication OK
LD<>(305) 1524 #9000
OUT H30.03
; rung 6
LD 1500.00
OR 1500.01
OUT H30.15

### Section Fault

; rung 0: Error / fault from devicenet drives. Flashing output when error active
LD GeneralFault_1
OR 3002.03
OR TimeOut_DoCommand
OR TimeOut_DoParameter
OR H30.01
OR H30.02
OR H30.03
OR FwdLimit_1
OR RevLimit_1
OUT Error  ; Collected error signal
AND P_1s
OUT 2.00

### Section DoCommand

; rung 0
SBN(092) 1

; rung 1: Load parameters to move profile
LD Step0DoCmd
+(400) NodeAddrDoCmd #2 AdresPointer  ; First address in devicenet area  for which node (drive) the command is valid.  // Calculate the relative address of the area for the drive
DIST(080) ValueDoCmd 3200 AdresPointer  ; Parameter MOV function. Size doubble word  // write value to low order word of Value
+(400) AdresPointer #1 AdresPointer
DIST(080) D101 3200 AdresPointer  // Write value to high order word of Value
@ORW(035) CommandMsgType #0020 Temporary  ; Number for the wanted command.  // Axis no= 1 OR with msg.type parameter. Creating ctrl axis no. and msg.type
@ORW(035) ResponseMsgtype #0020 AdresPointer  ; -Number for the wanted response  // Get response msg.type, and creat a similar for the response axis and msg.type
NASL(580) AdresPointer #8  // Rotate responseMSG to upper byte of word
ORW(035) Temporary AdresPointer Temporary  // collect ctrl and respons msg.types
+(400) NodeAddrDoCmd &1 AdresPointer  ; First address in devicenet area  for which node (drive) the command is valid.  // Write word Response and Command msg type
DIST(080) Temporary 3200 AdresPointer
SET Step1DoCmd
RSET Step0DoCmd
COLL(081) 3200 NodeAddrDoCmd Temp1  ; First address in devicenet area  for which node (drive) the command is valid., Parm Sub,Temp word for internal calculation  // Get word for control flags
ORW(035) #1 Temp1 Temp1  ; Parm Sub,Temp word for internal calculation  // Set bit 0 in control word. Load parameter
DIST(080) Temp1 3200 NodeAddrDoCmd  ; Parm Sub,Temp word for internal calculation, First address in devicenet area  for which node (drive) the command is valid.  // Write control to drive

; rung 2: Read the flag: Load complete by relative adressing
LD P_On
+(400) NodeAddrDoCmd #1 InternalAddressPointer  ; First address in devicenet area  for which node (drive) the command is valid., Parameter Sub  // Calculate address for getting Load complete flag
COLL(081) 3300 InternalAddressPointer 3010  ; Parameter Sub  // Read status flags
; rung 3: Step 2 of loading procedure. Reset load flag
LD LoadCompleteMirror  ; Read by relative addressing
AND Step1DoCmd
COLL(081) 3200 NodeAddrDoCmd Temp1  ; First address in devicenet area  for which node (drive) the command is valid., Parm Sub,Temp word for internal calculation  // Get Load Parameter flag, word
ANDW(034) #FFFE Temp1 Temp1  ; Parm Sub,Temp word for internal calculation  // Reset bit0, Load parameter
DIST(080) Temp1 3200 NodeAddrDoCmd  ; Parm Sub,Temp word for internal calculation, First address in devicenet area  for which node (drive) the command is valid.  // Write to drive
SET Step2DoCmd
RSET Step1DoCmd

; rung 4: Step 3 (last). Wait for Complete = 0 , and reset call for sub
LDNOT LoadCompleteMirror  ; Read by relative addressing
AND Step2DoCmd
+(400) NodeAddrDoCmd &1 AdresPointer  ; First address in devicenet area  for which node (drive) the command is valid.  // Move respons from relative drive to address for return of function
COLL(081) 3300 AdresPointer Temporary  // Get the response message type, 2.nd driver word
ANDW(034) Temporary #1F00 Temporary  // Mask only msg.type
NASR(581) Temporary #8  // Rotate to LSB
MOV(021) Temporary RespMsgType  ; Type of message response
+(400) AdresPointer &1 AdresPointer  // add to point next driver word
COLL(081) 3300 AdresPointer ResponseValue  ; Response from function call  // Get the 3.rd driver word, Lo order value
+(400) AdresPointer &1 AdresPointer
COLL(081) 3300 AdresPointer D111
MOV(021) #0 3091  // Reset word containing step and call for DoCommand
; rung 5: Test for error, if error activate read error code from drive
LD=(300) RespMsgType &14  ; Type of message response
SET ErrorCode  ; Activate SUB
; rung 6
RET(093)

### Section DoParameter

; rung 0: DoParameter Set and Get  parameters to and from device net servo drives. Based uopn relative addressing, using Devicenet memory area 3200 and 3300 for devicenet I/O
SBN(092) 2


; rung 1: Load Call parameters drive
LD Step0Parm
OUT TR0
+(400) NodeAdrDP #2 InternalAddressPointer  ; First address in devicenet area  for which node (drive) the command is valid., Parameter Sub  // Calculate parameter address
DIST(080) ValueDP 3200 InternalAddressPointer  ; Parameter set value for DoParameter, Parameter Sub  // Transfer parameter to drivearea, based upon First output address in device net area, defined at 3200
+(400) InternalAddressPointer #1 InternalAddressPointer  ; Parameter Sub
DIST(080) D121 3200 InternalAddressPointer  ; Parameter Sub  // Transfer high order part of parameter
MOV(021) AttributeGetDP D138  ; Attribute to get value for DoParameter
NASL(580) D138 #0008  // Rotate word to put Get attr. in hi order part
COLL(081) 3200 NodeAdrDP Temp1  ; First address in devicenet area  for which node (drive) the command is valid., Parm Sub,Temp word for internal calculation  // Get actual drive ctrl word
ANDW(034) Temp1 #00FF Temp2  ; Parm Sub,Temp word for internal calculation, Parm Sub, Temp word for internal calculation  // Remove hi order part of ctrl word
ORW(035) D138 Temp2 Temp1  ; Parm Sub, Temp word for internal calculation, Parm Sub,Temp word for internal calculation  // Combine hi and lo order part which are Attr get and ctrl flags
DIST(080) Temp1 3200 NodeAdrDP  ; Parm Sub,Temp word for internal calculation, First address in devicenet area  for which node (drive) the command is valid.  // Write to first word of drive
MOV(021) AttributeSetDP Temp2  ; Attribute to set value for DoParameter, Parm Sub, Temp word for internal calculation
NASL(580) Temp2 #0008  ; Parm Sub, Temp word for internal calculation
+(400) NodeAdrDP &1 InternalAddressPointer  ; First address in devicenet area  for which node (drive) the command is valid., Parameter Sub  // Calculate address for second word of drive
AND=(300) MessagetypeDP #1B  ; Set messagetype
@ORW(035) Temp2 #003B Temp1  ; Parm Sub, Temp word for internal calculation, Parm Sub,Temp word for internal calculation  // Using DoPositionControllerAttribute parameterset
LD TR0
AND=(300) MessagetypeDP #1F  ; Set messagetype
@ORW(035) Temp2 #003F Temp1  ; Parm Sub, Temp word for internal calculation, Parm Sub,Temp word for internal calculation  // Cmd2 = 00, Axis no= 1 part of 2, and msg.type= 1
LD TR0
DIST(080) Temp1 3200 InternalAddressPointer  ; Parm Sub,Temp word for internal calculation, Parameter Sub
RSET Step0Parm
SET Step1Parm
COLL(081) 3200 NodeAdrDP Temp1  ; First address in devicenet area  for which node (drive) the command is valid., Parm Sub,Temp word for internal calculation
ORW(035) #1 Temp1 Temp1  ; Parm Sub,Temp word for internal calculation
DIST(080) Temp1 3200 NodeAdrDP  ; Parm Sub,Temp word for internal calculation, First address in devicenet area  for which node (drive) the command is valid.

; rung 2: Read the falg: Load complete
LD P_On
+(400) NodeAdrDP #1 InternalAddressPointer  ; First address in devicenet area  for which node (drive) the command is valid., Parameter Sub
COLL(081) 3300 InternalAddressPointer 3010  ; Parameter Sub
; rung 3: Step 2 of loading procedure. Reset load flag
LD LoadCompleteMirror  ; Read by relative addressing
AND Step1Parm
COLL(081) 3200 NodeAdrDP Temp1  ; First address in devicenet area  for which node (drive) the command is valid., Parm Sub,Temp word for internal calculation
ANDW(034) #FFFE Temp1 Temp1  ; Parm Sub,Temp word for internal calculation
DIST(080) Temp1 3200 NodeAdrDP  ; Parm Sub,Temp word for internal calculation, First address in devicenet area  for which node (drive) the command is valid.
RSET Step1Parm
SET Step2Parm

; rung 4: Step 3 (last). Wait for Complete = 0 , and reset call for sub. And make response to get parameter
LD Step2Parm
ANDNOT LoadCompleteMirror  ; Read by relative addressing
+(400) NodeAdrDP &2 InternalAddressPointer  ; First address in devicenet area  for which node (drive) the command is valid., Parameter Sub  // Calculate address for return parameter value
COLL(081) 3300 InternalAddressPointer ReadParmDP  ; Parameter Sub, Read Parameter value for DoParameter
+(400) InternalAddressPointer &1 InternalAddressPointer  ; Parameter Sub  // Increase address for hi order word of return value
COLL(081) 3300 InternalAddressPointer D131  ; Parameter Sub
COLL(081) 3300 NodeAdrDP Temp1  ; First address in devicenet area  for which node (drive) the command is valid., Parm Sub,Temp word for internal calculation
ANDW(034) Temp1 #FF00 AttrOfReadParmDP  ; Parm Sub,Temp word for internal calculation, Attrinute of read Parameter value for DoParameter  // Remove lo order part
NASR(581) AttrOfReadParmDP #0008  ; Attrinute of read Parameter value for DoParameter  // Rotate the number of the returned attribute and make it a human value
MOV(021) #0 3092
; rung 5: Test for error, if error activate read error code from drive
LD P_Off
SET ErrorCode  ; Activate SUB
; rung 6
RET(093)

### Section ZeroSearch

; rung 0: This function work by setting parameters, and activate call to DoParameter
SBN(092) 0
; rung 1: 'Continuosly reading relatively for "InPosition" of the selected drive'
LD P_On
COLL(081) 3300 NodeAddres CopyDriveStatus
; rung 2: Sequence 6 steps for setting zerosearch, zerosearch velocity, and torque limit. And reset enable drive
LD ZeroSearch  ; Activate ZeroSearch
AND ZeroFirstscan
ANDNOT DoParameter  ; Execute
ANDNOT ZeroSeqLock
OR ZeroStep0
ANDNOT ZeroStep1
OUT ZeroStep0
; rung 3: First parameter is sent
%LD DoParameter  ; Execute
AND ZeroStep0
OR ZeroStep1
ANDNOT ZeroStep2
OUT ZeroStep1
TIMH(015) 0130 #20
; rung 4
LD T0130
AND ZeroStep1
OR ZeroStep2
ANDNOT ZeroStep3
OUT ZeroStep2
; rung 5: Second parameter is sent
%LD DoParameter  ; Execute
AND ZeroStep2
OR ZeroStep3
ANDNOT ZeroStep4
OUT ZeroStep3
TIMH(015) 0131 #20  ; T01a1
; rung 6
LD T01a1
AND ZeroStep3
OR ZeroStep4
ANDNOT ZeroStep5
OUT ZeroStep4

; rung 7: Third parameter is sent. Now set enable again
%LD DoParameter  ; Execute
AND ZeroStep4
OR ZeroStep5
ANDNOT ZeroStep6
OUT ZeroStep5
; rung 8: Wait for In position no longer active
LDNOT 3089.02  ; $?St$Bk?_#[397] / Copy of drive "InPosition" $?St$Bk?_#[397]
AND 3089.07  ; Copy of drive Enabled
AND ZeroStep5
OR ZeroStep6
OUT ZeroStep6
; rung 9: This late setting ensures the edge triggering
LD P_On
SET ZeroFirstscan
; rung 10: Wait for InPosition reached and end function call
@LD 3089.02  ; $?St$Bk?_#[397] / Copy of drive "InPosition" $?St$Bk?_#[397]
AND ZeroStep6
MOV(021) #0 3093
; rung 11: Sequence lock
LD ZeroStep0
OR ZeroSeqLock
OUT ZeroSeqLock

; rung 12: Setting parameters for calling DoPositionControllerAttribute. Setting type of zerosearch
LD ZeroStep0
MOV(021) NodeAddres NodeAdrDP  ; First address in devicenet area  for which node (drive) the command is valid.
MOV(021) #1B MessagetypeDP  ; Set messagetype
MOVL(498) TypeZeroSearch ValueDP  ; Parameter set value for DoParameter
MOV(021) &100 AttributeSetDP  ; Attribute to set value for DoParameter
MOV(021) &102 AttributeGetDP  ; Attribute to get value for DoParameter
; rung 13: Setting parameters for calling DoPositionControllerAttribute, setting Torque limit
LD ZeroStep2
MOVL(498) TorqueLimit ValueDP  ; Parameter set value for DoParameter
MOV(021) &103 AttributeSetDP  ; Attribute to set value for DoParameter
; rung 14: Setting parameters for calling DoPositionControllerAttribute, setting search velocity
LD ZeroStep4
MOVL(498) ZeroSearchVelocity ValueDP  ; Parameter set value for DoParameter
MOV(021) &102 AttributeSetDP  ; Attribute to set value for DoParameter
; rung 15: Activate call to DoParameter
@LD ZeroStep0
@OR ZeroStep2
@OR ZeroStep4
SET DoParameter  ; Execute

; rung 16: Set Enable for servo drive relatively adressed
@LD ZeroStep5
COLL(081) 3200 NodeAddres D188  // Read control bit
ORW(035) D188 #0080 D188  // Set bit 7, which is enable servo drive
DIST(080) D188 3200 NodeAddres  // Write control bit
; rung 17
RET(093)

### Section MoveSub
; MoveSub is subprogram for MOVE function, this is the sequential action for transferring 3 parameters and maintain actual position during positioning

; rung 0
SBN(092) 3
; rung 1: 'Continuosly reading relatively for "InPosition" of the selected drive'
LD P_On
COLL(081) 3300 MovAddr 3088
; rung 2: Sequence 4 steps for setting acc.,velocity,targetposition, and afterwards to read actual position until in position
LD MoveFunction  ; Activate
AND MoveFirstscan
ANDNOT MoveSeqLock
OR MoveStep0
ANDNOT MoveStep1
OUT MoveStep0
; rung 3: Waiting for finished DoCommand, by falling edge.
%LD DoCommand  ; Execute
AND MoveStep0
OR MoveStep1
ANDNOT MoveStep2
OUT MoveStep1
TIMH(015) 0120 #5
; rung 4
LD T0120
AND MoveStep1
OR MoveStep2
ANDNOT MoveStep3
OUT MoveStep2
; rung 5: Waiting for finished DoCommand, by falling edge.
%LD DoCommand  ; Execute
AND MoveStep2
OR MoveStep3
ANDNOT MoveStep4
OUT MoveStep3
TIMH(015) 0121 #5
; rung 6
LD T0121
AND MoveStep3
OR MoveStep4
ANDNOT MoveStep5
OUT MoveStep4

; rung 7: Waiting for finished DoCommand, by falling edge.
%LD DoCommand  ; Execute
AND MoveStep4
OR MoveStep5
ANDNOT MoveStep0
OUT MoveStep5
TIMH(015) 0122 #5
; rung 8: Request actual position during running
LD MoveStep5
AND T0122
OR MoveStep6
ANDNOT MoveStep0
OUT TR0
OUT MoveStep6
AND T0123
SET MoveCyclicCall
LD TR0
ANDNOT T0123
TIM 0123 #2  // Cycle for updating actual position
; rung 9: Position reached, request last actual position to see target position, and thereafter finish calling.
LD MoveCyclicCall
AND MoveStep6
AND 3088.02  ; $?St$Bk?_#[396] / Copy of status "InPosition"$?St$Bk?_#[396]
OR MoveStep7
OUT MoveStep7
; rung 10: Set after first scan to ensure edge triggering in sub
LD P_On
SET MoveFirstscan
; rung 11: Transfer repons to MOVE function response
@LD P_0_02s
OR MoveStep7
MOVL(498) ResponseValue D170  ; Response from function call
; rung 12: Position reached, waiting end of last call.
%LD DoCommand  ; Execute
AND MoveStep7
MOV(021) #0 3080

; rung 13: Sequence lock
LD MoveStep0
OR MoveSeqLock
OUT MoveSeqLock
; rung 14: Parameters for setting Velocity
LD MoveStep0
MOV(021) #2 CommandMsgType  ; Number for the wanted command.
MOV(021) MovAddr NodeAddrDoCmd  ; First address in devicenet area  for which node (drive) the command is valid.
MOVL(498) MovVel ValueDoCmd  ; Parameter MOV function. Size doubble word
; rung 15: Parameters for setting acceleration
LD MoveStep2
MOV(021) #3 CommandMsgType  ; Number for the wanted command.
MOVL(498) MovAcc ValueDoCmd  ; Parameter MOV function. Size doubble word
; rung 16: Parameters for setting target position
LD MoveStep4
MOV(021) #1 CommandMsgType  ; Number for the wanted command.
MOVL(498) MovTargetPos ValueDoCmd  ; Parameter MOV function. Size doubble word

; rung 17: Call routine for DoCommand
@LD MoveStep0
@OR MoveStep2
@OR MoveStep4
OR MoveCyclicCall
SET DoCommand  ; Execute
RSET MoveCyclicCall
; rung 18
RET(093)

### Section Initialize

; rung 0: This function work by setting parameters, and activate call to DoParameter
SBN(092) 5
; rung 1: Sequence 6 steps for setting zerosearch, zerosearch velocity, and torque limit. Send first
LD InitializeFun  ; Activate Initialize
ANDNOT DoCommand  ; Execute
AND FirstInitScan
ANDNOT InitSeqLock
OR InitStep0
ANDNOT InitStep1
OUT InitStep0
; rung 2: 1. parameter is sent, now wait
%LD DoCommand  ; Execute
AND InitStep0
OR InitStep1
ANDNOT InitStep2
OUT InitStep1
TIMH(015) 0140 #20  ; DelayI1
; rung 3: Activate next parm set
LD DelayI1
AND InitStep1
OR InitStep2
ANDNOT InitStep3
OUT InitStep2
; rung 4: Second has been sent, now wait
%LD DoCommand  ; Execute
AND InitStep2
OR InitStep3
ANDNOT InitStep4
OUT InitStep3
TIMH(015) 0141 #5  ; DelayI2
; rung 5: Send the last
LD DelayI2
AND InitStep3
OR InitStep4
ANDNOT InitStep5
OUT InitStep4

; rung 6: 3.rd has been sent
%LD DoCommand  ; Execute
AND InitStep4
OR InitStep5
ANDNOT InitStep0
OUT InitStep5
TIMH(015) 0142 #5  ; DelayI3
; rung 7: Ensures edgetriggering
LD P_On
SET FirstInitScan
; rung 8: Now wait for ending function
LD InitStep5
AND DelayI3
ANDNOT InitStep0
MOV(021) #0 3095
; rung 9: Sequence lock
LD InitStep0
OR InitSeqLock
ANDNOT 3095.06
OUT InitSeqLock
; rung 10: Setting parameters for calling DoPositionControllerAttribute, setting maximum velocity
LD InitStep0
MOV(021) InitNodeAdr NodeAddrDoCmd  ; Parm for initialize, First address in devicenet area  for which node (drive) the command is valid.
MOV(021) &2 CommandMsgType  ; Number for the wanted command.
MOVL(498) InitMaxVelocity ValueDoCmd  ; Parm for initialize, Parameter MOV function. Size doubble word
MOV(021) &0 ResponseMsgtype  ; -Number for the wanted response

; rung 11: Setting parameters for calling DoPositionControllerAttribute, setting Acceleration
LD InitStep2
MOVL(498) InitAcceleration ValueDoCmd  ; Parm for initialize, Parameter MOV function. Size doubble word
MOV(021) &103 CommandMsgType  ; Number for the wanted command.
; rung 12: Setting parameters for calling DoCommand, setting Torque limit
LD InitStep4
MOVL(498) InitTorqueLimit ValueDoCmd  ; Parm for initialize, Parameter MOV function. Size doubble word
MOV(021) &5 CommandMsgType  ; Number for the wanted command.
; rung 13: Activate call to DoCommand
@LD InitStep0
@OR InitStep2
@OR InitStep4
SET DoCommand  ; Execute
; rung 14
RET(093)

### Section END
; rung 0
END(001)